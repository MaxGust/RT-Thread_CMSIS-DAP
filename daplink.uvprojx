# Keil uVision project daplink.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F205RGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: daplink
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F205xx,STM32F2,RTE_CMSIS_RTOS2
  c include: .\dap;.;.\rt-thread\include;.\rt-thread\include\libc;.\packages\CMSIS-v5.0.0\CMSIS_5\CMSIS\RTOS2\Include;.\rt-thread\components\drivers\include;.\rt-thread\components\drivers\include\drivers;.\rt-thread\components\drivers\include\ipc;.\rt-thread\components\finsh
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c board.c
    ./dap/: DAP_config.h USBD_User_CustomClass_0.c
  group DAP
    ./dap/: DAP.c JTAG_DP.c SW_DP.c SWO.c
  group cmsis
    ./packages/CMSIS-v5.0.0/RTOS2/RT-Thread/src/: cmsis_rtthread.c os_systick.c
  group rt-thread
    ./rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
    ./rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ./rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
    ./rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group shell
    ./rt-thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_file.c shell.c symbol.c
  group driver
    ./: drv_common.c drv_usart.c drv_gpio.c
  group device
    ./rt-thread/components/drivers/serial/: serial.c
    ./rt-thread/components/drivers/misc/: pin.c
software components: CMSIS Driver:USB Device:Custom 1.0.0, CMSIS:CORE 5.4.0, USB:CORE 6.14.1, USB:Device 6.14.1, USB:Device:CDC 6.14.1, USB:Device:Custom Class 6.14.1, CMSIS Driver:USB Device:Full-speed 2.18, Device:STM32Cube Framework:Classic 1.2.1, Device:STM32Cube HAL:Common 1.2.1, Device:STM32Cube HAL:Cortex 1.2.1, Device:STM32Cube HAL:DMA 1.2.1, Device:STM32Cube HAL:GPIO 1.2.1, Device:STM32Cube HAL:PWR 1.2.1, Device:STM32Cube HAL:RCC 1.2.1, Device:STM32Cube HAL:UART 1.2.1, Device:STM32Cube HAL:USART 1.2.1, Device:Startup 2.2.1
